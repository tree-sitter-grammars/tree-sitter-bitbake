require foo.inc
