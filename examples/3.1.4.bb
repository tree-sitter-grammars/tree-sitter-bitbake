A = "aval"
B = "pre${A}post"
BAR = "${FOO}"
