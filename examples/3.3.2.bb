A${B} = "X"
B = "2"
A2 = "Y"
