FOO = "bar \
       baz \
       qaz"
FOO = "barbaz"
FOO = "bar\
baz"
