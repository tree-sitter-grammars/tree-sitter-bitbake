VARIABLE = "value"
VARIABLE = " value"
VARIABLE = "value "
VARIABLE = ""
VARIABLE = " "
VARIABLE = 'I have a " in my value'
