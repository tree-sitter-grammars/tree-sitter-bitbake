deltask printdate

do_b[noexec] = "1"
