A ?= "aval"
