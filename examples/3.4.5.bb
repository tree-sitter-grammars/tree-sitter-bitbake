INHERIT += "abc"
INHERIT += "autotools pkgconfig"
