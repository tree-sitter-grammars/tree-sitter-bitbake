B = "bval"
B .= "additionaldata"
C = "cval"
C =. "test"
