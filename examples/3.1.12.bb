inherit foo
FOO = "initial"

FOO += "val"

FOO:append = " val"
