FOO[a] = "abc"
FOO[b] = "123"
FOO[a] += "456"

CACHE[doc] = "The directory holding the cache of the metadata."
