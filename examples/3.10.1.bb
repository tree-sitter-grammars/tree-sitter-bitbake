addtask printdate after do_fetch before do_build
